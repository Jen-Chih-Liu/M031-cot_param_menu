# Keil uVision project USBD_VCOM_SerialEmulator.uvproj, settings and files
target USBD_VCOM_SerialEmulator (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: USBD_VCOM_SerialEmulator
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\cot_menu;..\cot_menu\examples\hmi\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
    ../cot_menu/: cot_menu.c
    ../cot_menu/examples/hmi/src/: hmi_camera.c hmi_more_set.c hmi_music.c hmi_set.c hmi_video.c mainhmi.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c clk.c uart.c retarget.c
  group cot_menu
    ../cot_menu/: cot_menu.c
